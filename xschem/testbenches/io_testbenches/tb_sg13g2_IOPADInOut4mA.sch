** sch_path: xschem/testbenches/io_testbenches/tb_sg13g2_IOPADInOut4mA.sch
**.subckt tb_sg13g2_IOPADInOut4mA
Vin net1 GND PULSE(0 1.2 0 40p 40p 1n 2n)
XX16 out_a bondpad size=80u shape=0 padtype=0
V1 IO_vdd GND 1.2
V2 IO_iovdd GND 3.3
V3 IO_vss GND 0
V4 IO_iovss GND 0
V5 GND sub! 0
R1 net1 in_a 10 m=1
x1 IO_iovdd IO_iovss in_a IO_vss IO_vdd IO_vss IO_vdd out_a sg13g2_IOPadInOut4mA
**** begin user architecture code

.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.include diodes.lib
.include sg13g2_bondpad.lib
.include /foss/pdks/ihp-sg13g2/libs.ref/sg13g2_stdcell/spice/sg13g2_stdcell.spice



.options method=gear reltol=1e-1 abstol=1e-1 vntol=1e-1
.control
 tran 10p 20n 10p
 plot v(in_a) v(out_a)
 plot i(Vin)
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL sub!
.end
